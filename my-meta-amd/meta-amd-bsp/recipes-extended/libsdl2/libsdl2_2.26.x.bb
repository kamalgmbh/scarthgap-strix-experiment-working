# xen 4.16.1 release sha
LICENSE = "GPL-2.0-only"
SRCREV ?= "0bfeed061b10ea7dd37c88d9bae1824bad760f3a"

XEN_REL ?= "SDL"
XEN_BRANCH ?= "release-2.26.x"

SRC_URI = " \
    git://github.com/libsdl-org/SDL.git;branch=${XEN_BRANCH};protocol=https \
    file://0001-Updated-to-version-2.27.0-for-development.patch \
    file://0002-Update-SDL-info-and-Xcode-marketing-version-with-ver.patch \
    file://0003-Update-SDL-info-and-Xcode-marketing-version-to-2.27..patch \
    file://0004-android.mk-LOCAL_EXPORT_C_INCLUDES-does-not-need-to-.patch \
    file://0005-.wikiheaders-options-Move-SDL2-documentation-to-a-su.patch \
    file://0006-Revert-Added-Linux-mappings-for-the-Logitech-G29-in-.patch \
    file://0007-Removed-G29-from-controller_type.c.patch \
    file://0008-Testing-the-wiki-disregard-this-commit.patch \
    file://0009-Sync-SDL2-wiki-header.patch \
    file://0010-adds-GDK-suspend-resume-basic-handling-6596.patch \
    file://0011-fix-dynapi-after-SDL_GDKSuspendComplete-addition.patch \
    file://0012-SDL_cocoaopengl.h-ensure-CVDisplayLinkRef-is-defined.patch \
    file://0013-Check-build-time-SDK-in-LoadMainMenuNibIfAvailable.patch \
    file://0014-SDL_mfijoystick.m-fix-build-with-Xcode-9.patch \
    file://0015-wayland-Fix-libdecor_dispatch-signature.patch \
    file://0016-vulkan_metal.h-Make-compatible-with-ObjC-ARC.patch \
    file://0017-Avoid-use-of-deprecated-egrep-fgrep.patch \
    file://0018-wayland-Fix-build-when-not-using-the-shared-Wayland-.patch \
    file://0019-added-missing-FGREP-to-Makefile.in.-fixed-syntax.-re.patch \
    file://0020-SDL_mfijoystick.m-remove-VLA-so-that-projects-can-be.patch \
    file://0021-cmake-add-X11-include-dir-to-check-dirs.patch \
    file://0022-Add-bitdraw.h-remove-non-working-stub-class.patch \
    file://0023-cmake-add-support-for-some-BSD-s-wscons-input.patch \
    file://0024-cmake-find-libudev-library-so-it-gets-priority.patch \
    file://0025-cmake-make-all-assembly-options-depend-on-SDL_ASSEMB.patch \
    file://0026-cmake-test-for-lsx-and-lasx-intrinsics-for-loongarch.patch \
    file://0027-cocoa-Patched-to-compile-on-macOS-SDK-10.10.patch \
    file://0028-Temporary-hack-to-address-performance-issues-in-http.patch \
    file://0029-Fix-build-with-Xcode-7.patch \
    file://0030-SDL_ResampleAudio-Fix-float-accumulation-error.patch \
    file://0031-skip-ci-Solaris-getexecname-returns-argv-0.patch \
    file://0032-Cleanup-add-brace-6545.patch \
    file://0033-Add-8BitDo-to-the-list-of-Xbox-360-third-party-vendo.patch \
    file://0034-Added-support-for-the-8BitDo-Ultimate-Wired-Controll.patch \
    file://0035-Fix-broken-solaris-build.-missing-brace.patch \
    file://0036-Add-support-for-the-8BitDo-Ultimate-Wireless-2.4GHz-.patch \
    file://0037-Added-support-for-the-Xbox-Elite-controller-paddles-.patch \
    file://0038-thread-fix-inconsistent-return-values.patch \
    file://0039-thread-return-1-from-SDL_SemWaitTimeout-if-semaphore.patch \
    file://0040-Fixed-bug-6698-VISA-wrong-check-sceKernelPollSema.patch \
    file://0041-thread-code-style.patch \
    file://0042-Fixed-bug-6698-VISA-wrong-check-sceKernelPollSema.patch \
    file://0043-Fixed-building-on-Windows-with-SDL_VIDEO-OFF.patch \
    file://0044-cmake-use-target_link_libraries-to-pass-Wl-undefined.patch \
    file://0045-video-fix-error-messages.patch \
    file://0046-dynapi-Abstract-out-the-environment-variable-name.patch \
    file://0047-cmake-move-platform-detection-to-cmake-sdl-paltform..patch \
    file://0048-Support-wayland-fractional-scale-protocol.patch \
    file://0049-SDL_test_md5.h-fix-MD5UINT4-type-to-be-really-32-bit.patch \
    file://0050-Revert-SDL_test_md5.h-fix-MD5UINT4-type-to-be-really.patch \
    file://0051-Update-for-SDL3-coding-style-6717.patch \
    file://0052-Fixed-build-after-cherry-pick-of-5750bcb174300011b91.patch \
    file://0053-Fixed-crash-if-GetRectDisplayIndex-is-called-before-.patch \
    file://0054-Fixed-Victrix-FS-Pro-V2-controller-hang-on-reboot.patch \
    file://0055-Reverted-code-formatting-for-Apple-platforms.patch \
    file://0056-Re-enabled-support-for-third-party-PS3-controllers.patch \
    file://0057-Added-support-for-the-HORIPAD-Pro-for-Xbox-Series-X.patch \
    file://0058-Added-support-for-the-Logitech-Cordless-Precision-PS.patch \
    file://0059-restore-SDL_malloc.c-original-formatting.patch \
    file://0060-Small-format-changed-using-clang-format-15.0.2-1.patch \
    file://0061-SDL_main.h-added-field-to-SDL_GDKSuspendComplete-doc.patch \
    file://0062-Removed-check-for-_HAVE_STDINT_H-which-nobody-define.patch \
    file://0063-Clang-Tidy-fixes-6725.patch \
    file://0064-Fixed-build-after-d0bbfdbfb881e5407911d84c12899bd5b4.patch \
    file://0065-Detect-the-G923-Xbox-style-and-PXN-V900-PS3-mode-as-.patch \
    file://0066-Fixed-Apple-build-after-d0bbfdbfb881e5407911d84c1289.patch \
    file://0067-build-fixes-after-d0bbfdbfb881e5407911d84c12899bd5b4.patch \
    file://0068-Fix-formatting-on-Wayland-and-Pipewire-function-sign.patch \
    file://0069-Commented-out-syntax-that-causes-Visual-Studio-2019-.patch \
    file://0070-Fix-Conditional-jump-or-move-depends-on-uninitialise.patch \
    file://0071-Fix-wrong-clang-tidy-modification.-This-is-an-intege.patch \
    file://0072-Detect-Logitech-PRO-Racing-Wheel-as-wheel.patch \
    file://0073-reverted-const-removal-from-SDL_NewAudioStream-in-co.patch \
    file://0074-tests-avoid-redefinition-warnings-for-MSVC-_CRT_-_NO.patch \
    file://0075-Fixed-centering-the-D-pad-on-some-joysticks.patch \
    file://0076-Clarified-where-the-paddle-locations-are.patch \
    file://0077-Added-support-for-the-DualSense-Edge-paddles.patch \
    file://0078-Use-the-correct-name-for-the-DualSense-controllers.patch \
    file://0079-Fixed-build.patch \
    file://0080-wayland-Handle-the-Num-Lock-and-Caps-Lock-modifiers-.patch \
    file://0081-Fixed-memory-leak-when-removing-existing-displays.patch \
    file://0082-Added-SDL_DISPLAYEVENT_MOVED-to-detect-when-display-.patch \
    file://0083-Make-sure-the-display-list-is-up-to-date-for-window-.patch \
    file://0084-Added-logging-for-SDL_DISPLAYEVENT_MOVED.patch \
    file://0085-Added-test-event-logging-for-SDL_WINDOWEVENT_ICCPROF.patch \
    file://0086-Fixed-build.patch \
    file://0087-docs-Note-that-you-don-t-need-to-free-SDL_GetDefault.patch \
    file://0088-SDL_dynapi_procs-fixed-SDL_UIKitRunApp-prototype-see.patch \
    file://0089-Update-DYNAPI-SDL_WinRTRunApp-prototype-which-was-wr.patch \
    file://0090-cmake-use-FindALSA.cmake-to-find-ALSA-library.patch \
    file://0091-N3DS-Backport-semaphore-fixes-from-6776.patch \
    file://0092-Added-support-for-the-STRIKEPAD-PS4-Grip-Add-on-to-t.patch \
    file://0093-wayland-Set-xdg-surface-geometry.patch \
    file://0094-wasapi-Fixed-incorrect-assertions.patch \
    file://0095-Don-t-try-to-open-the-Razer-Huntsman-Elite-keyboard-.patch \
    file://0096-Detect-display-change-when-fullscreen-desktop-window.patch \
    file://0097-DBus-add-a-reference-to-the-connection.patch \
    file://0098-Added-support-for-clang-thread-safety-analysis.patch \
    file://0099-Fixed-crash-in-SDL_PrivateGameControllerRefreshMappi.patch \
    file://0100-testime.c-fix-wrong-in-switch.patch \
    file://0101-Note-that-the-NACON-Daija-Arcade-Stick-is-an-arcade-.patch \
    file://0102-Sorted-PS4-controllers-note-that-the-NACON-Wireless-.patch \
    file://0103-Android-audio-device-selection-6824.patch \
    file://0104-Fixed-compiler-warning.patch \
    file://0105-Fixed-compiler-warning.patch \
    file://0106-Android-make-Detect-devices-common-between-aaudio-an.patch \
    file://0107-Android-JAVA-DetectDevices-is_capture-is-inverted-68.patch \
    file://0108-Android-active-driver-check-6850.patch \
    file://0109-Don-t-send-Razer-devices-the-Sony-third-party-query-.patch \
    file://0110-gdk-Add-support-for-building-with-OpenGL-on-Xbox.patch \
    file://0111-Fix-dynapi-signature-for-SDL_GDKSuspendComplete.patch \
    file://0112-Fix-GDK-OpenGL-build-error.patch \
    file://0113-Add-SDL_HINT_WINDOWS_ENABLE_MENU_MNEMONICS.patch \
    file://0114-kmsdrm-Fix-wrong-check-on-KMSDRM_CreateWindow.patch \
    file://0115-render-only-enable-clipping-when-the-rectangle-is-va.patch \
    file://0116-editorconfig-remove-trailing-whitespace-in-source-co.patch \
    file://0117-Fix-SDL_CreateThreadWithStackSize-not-passing-staack.patch \
    file://0118-SDL_thread.h-fix-beginthread-param-of-SDL_CreateThre.patch \
    file://0119-SDL_thread.h-fix-SDL_CreateThreadWithStackSize-macro.patch \
    file://0120-Make-sure-we-match-the-same-way-when-adding-a-mappin.patch \
    file://0121-Fixed-getting-the-VID-PID-of-a-virtual-joystick.patch \
    file://0122-Fixed-keyboard-scancode-mapping-for-parenthesis.patch \
    file://0123-Fixed-documentation-for-SDL_JoystickGetDeviceInstanc.patch \
    file://0124-SDL_dynapi.c-LoadLibraryA-returns-HMODULE.patch \
    file://0125-windows-more-HANDLE-HMODULE-changes.patch \
    file://0126-Android-inverse-LandscapeLeft-and-LandscapeRight-see.patch \
    file://0127-Android-orientation-check-for-exact-match-to-Portrai.patch \
    file://0128-SDL2-backport-SDL_CalculateYUVSize-that-checks-for-Y.patch \
    file://0129-render-SDL_yuv_sw.c-fix-build-after-commit-d234f7a.patch \
    file://0130-Wayland-Drag-and-Drop-find-the-current-window.patch \
    file://0131-Improved-handling-of-binding-buttons-and-axes.patch \
    file://0132-Added-support-for-the-ThrustMaster-eSwap-PRO-Control.patch \
    file://0133-Fixed-line-wrapping-for-HID-packet-dump.patch \
    file://0134-Added-support-for-the-ThrustMaster-eSwap-PRO-Control.patch \
    file://0135-Fixed-bug-6990-fix-computation-of-alpha-in-BlitRGBto.patch \
    file://0136-fix-computation-of-alpha-in-BlitRGBtoRGBPixelAlphaMM.patch \
    file://0137-wayland-Fallback-to-default-cursor-if-chosen-one-was.patch \
    file://0138-cmake-fix-detection-of-library-functions-when-Werror.patch \
    file://0139-cmake-check-for-math-library-functions-even-in-the-a.patch \
    file://0140-Fixed-infinite-loop-shutting-down-WGI-controllers.patch \
    file://0141-cmake-do-all-compile-tests-with-D_GNU_SOURCE-1.patch \
    file://0142-cmake-CheckPTHREAD-remove-_GNU_SOURCE-define-after-b.patch \
    file://0143-Fix-loongarch64-support.patch \
    file://0144-Updated-copyright-for-2023.patch \
    file://0145-SDLAudioManager.java-Fixed-the-support-for-Android-o.patch \
    file://0146-Remove-dummy-flag.patch \
    file://0147-Using-UV-instead-of-STQ.patch \
    file://0148-SDL_dynapi.c-add-extern-C-guards-just-in-case.patch \
    file://0149-hidapi-switch-Add-user-calibration-support.patch \
    file://0150-Fixed-the-hat_map-to-avoid-segmentation-fault.patch \
    file://0151-wayland-Perform-a-round-trip-when-maximizing-and-res.patch \
    file://0152-wayland-Don-t-try-to-restore-non-resizable-windows.patch \
    file://0153-Revert-wayland-Don-t-try-to-restore-non-resizable-wi.patch \
    file://0154-Use-filesystem-drivers.patch \
    file://0155-fix-prefix-path-not-resolving-symlinks.patch \
    file://0156-n3ds-fix-exported-libraries-of-n3ds.patch \
    file://0157-ci-don-t-require-EXTRA_-prefix-on-input-environment-.patch \
    file://0158-SDL_CreateAudioStream-check-for-invalid-parameters.patch \
    file://0159-SDL_test_harness-fix-memory-leak-when-generated-seed.patch \
    file://0160-add-support-for-libsamplerate-s-linear-resampling-mo.patch \
    file://0161-autotools-Add-check-for-libdecor-get-min-max-functio.patch \
    file://0162-regenerated-configure-script.patch \
    file://0163-wayland-Set-APPLICATION-scancode-name-to-Menu.patch \
    file://0164-typo-fix-to-config.sub.patch \
    file://0165-Blacklist-Konami-Amusement-Controllers-From-HIDAPI.patch \
    file://0166-Update-SDL_vitagles_pvr.c.patch \
    file://0167-wayland-Enforce-or-override-libdecor-minimum-window-.patch \
    file://0168-Support-MIN-MAX-blend-on-OpenGL-ES.patch \
    file://0169-vita-PVR-needs-to-link-to-sceIme_stub-library.patch \
    file://0170-Support-MIN-MAX-blend-on-opengles2.patch \
    file://0171-cmake-allow-disabling-OpenGL-support-when-building-w.patch \
    file://0172-vita-fix-reformatting-error-in-SDL_vtagl_pvr.c.patch \
    file://0173-vita-add-missing-static-libraries-for-using-gles-wit.patch \
    file://0174-ci-test-PVR_PSP2-gles-gl-and-gib-gles.patch \
    file://0175-SDL_atomic.h-Update-SDL_CPUPauseInstruction-for-Watc.patch \
    file://0176-wikiheaders-Add-a-threadsafety-tag-to-document-threa.patch \
    file://0177-wikiheaders-Allow-markdown-in-the-wikipreamble-strin.patch \
    file://0178-wikiheaders-Link-to-the-SDL3-wiki-in-the-preamble.patch \
    file://0179-Fix-For-issue-6948-6991.patch \
    file://0180-Note-that-version.rc-is-public-domain.patch \
    file://0181-cmake-assume-autotools-static-libraries-with-lib-pre.patch \
    file://0182-macOS-fix-initial-Metal-drawable-size-in-certain-mul.patch \
    file://0183-Added-gamepad-mappings-for-the-Xin-Mo-Dual-Arcade-Fi.patch \
    file://0184-Fixed-sort_controllers.py-and-resorted-game-controll.patch \
    file://0185-Don-t-accept-official-mappings-for-controllers-that-.patch \
    file://0186-dynapi-cast-GetProcAddress-result-to-void.patch \
    file://0187-opengl-make-SDL_opengl_glext.h-s-include-compatible-.patch \
    file://0188-Adds-Stadia-BT-mapping.patch \
    file://0189-include-add-comment-documenting-the-change-s-to-SDL_.patch \
    file://0190-replaced-line-comments-in-public-header.patch \
    file://0191-Add-Linux-mapping-for-8BitDo-Pro-2-Wired-Controller-.patch \
    file://0192-Added-Elecom-8button-gamepad.patch \
    file://0193-Sorted-controller-list.patch \
    file://0194-Setting-the-same-mouse-cursor-twice-is-a-no-op.patch \
    file://0195-Fixed-warning-running-a-command-queue-without-any-ve.patch \
    file://0196-windows-SDL_systhread.c-remove-some-dead-code.patch \
    file://0197-make-sure-to-not-enable-SDL_PASSED_BEGINTHREAD_ENDTH.patch \
    file://0198-Added-support-for-the-Logitech-ChillStream.patch \
    file://0199-fix-build-after-the-Logitech-ChillStream-patch.patch \
    file://0200-Enable-paddles-on-the-Xbox-Elite-controller-when-con.patch \
    file://0201-Dynamically-update-the-serial-number-if-it-isn-t-ava.patch \
    file://0202-Fixed-mis-detecting-the-share-button-on-the-Xbox-con.patch \
    file://0203-Note-the-Google-Stadia-controller-doesn-t-support-ru.patch \
    file://0204-Make-sure-we-synchronously-re-enable-USB-reporting-m.patch \
    file://0205-Fixed-MFI-controller-being-opened-while-HIDAPI-contr.patch \
    file://0206-Backport-simplify-flags-PR-7220.patch \
    file://0207-emscripten-Update-deprecated-calls-to-EM_ASM.patch \
    file://0208-Add-Hori-Pokken-Tournament-DX-Pro-Pad.patch \
    file://0209-Sorted-controller-list.patch \
    file://0210-Fixed-audio.patch \
    file://0211-Guard-against-_USE_MATH_DEFINES-redefinition.patch \
    file://0212-Fixed-bug-7302-Memory-leak-in-SDL_SetMouseSystemScal.patch \
    file://0213-cmake-fix-detection-of-pthread_setname_np-on-Apple-p.patch \
    file://0214-cmake-really-fix-detection-of-pthread_setname_np-on-.patch \
    file://0215-look-for-clock_gettime-in-libc-first-then-in-librt-i.patch \
    file://0216-Fixed-handling-simple-mode-PS4-reports.patch \
    file://0217-Map-the-Android-MENU-button-back-to-the-SDL-MENU-key.patch \
    file://0218-Fixed-Steam-Runtime-sandbox-detection.patch \
    file://0219-Fix-potential-de-referencing-null-pointer-in-SDL_EVD.patch \
    file://0220-Hold-the-joystick-lock-while-opening-the-HID-device-.patch \
    file://0221-ci-install-pkg-config-on-Macos-runner.patch \
    file://0222-Added-other-names-for-the-DragonRise-Inc.-Wired-Whee.patch \
    file://0223-Fix-window-size-in-X11-when-window-manager-refuses-t.patch \
    file://0224-SDL_x11dyn.h-include-XInput2.h-also-for-Xfixes.patch \
    file://0225-Fix-GetGlobalMouseState-when-xi2-is-not-available-at.patch \
    file://0226-Fixed-typo-thanks-Iniquitatis.patch \
    file://0227-include-Fix-symbols-in-public-headers-that-start-wit.patch \
    file://0228-windows-gles-correct-indentation.patch \
    file://0229-windows-gles-do-not-unload-EGL-when-context-is-destr.patch \
    file://0230-cocoa-gles-do-not-unload-EGL-when-context-is-destroy.patch \
    file://0231-Added-support-for-the-Razer-Wolverine-V2-controllers.patch \
    file://0232-Fixed-rumble-caps-for-the-Nintendo-Joy-Con-controlle.patch \
    file://0233-Removed-duplicated-conditional.patch \
    file://0234-Added-support-for-the-Turtle-Beach-REACT-R-and-Recon.patch \
    file://0235-Fixed-the-share-button-on-the-ThrustMaster-eSwap-PRO.patch \
    file://0236-Fixed-the-packet-size-for-Xbox-One-controllers.patch \
    file://0237-Rumbling-the-Google-Stadia-Controller-over-Bluetooth.patch \
    file://0238-De-duplicate-Google-Stadia-controllers-on-macOS.patch \
    file://0239-resampler-Work-at-double-precision-on-x86-64-machine.patch \
    file://0240-fix-MSVC-build-failures-in-CI-after-commit-1e5e8e2f.patch \
    file://0241-Fixed-view-frame-from-flipping-back-and-forth-betwee.patch \
    file://0242-Added-support-for-the-Backbone-One-PlayStation-Editi.patch \
    file://0243-Changed-the-VID-PID-used-for-the-Backbone-One-contro.patch \
    file://0244-wikiheaders-Work-to-make-the-wiki-exist-primarily-in.patch \
    file://0245-wikibridge-Fixes-for-manpage-generation-from-Markdow.patch \
    file://0246-wikiheaders-fixed-see-also-conversion.patch \
    file://0247-Sync-wiki-headers.patch \
    file://0248-Fixed-relative-mouse-motion-over-remote-desktop.patch \
    file://0249-wikiheaders-Fix-wikilinks-inside-code-sections-a-lit.patch \
    file://0250-x11-Fix-duplicate-Xinput2-event-reception.patch \
    file://0251-USE_DEV_RANDOM-close-the-file-descriptor-even-in-the.patch \
    file://0252-Added-mapping-for-DualSense-Edge-Wireless-Controller.patch \
    file://0253-wikiheaders-fixed-wikilinks-in-Markdown-code-section.patch \
    file://0254-Fixed-locking-up-the-Logitech-F310-with-the-PlayStat.patch \
    file://0255-wikiheaders-Bridge-README-files-in-the-docs-director.patch \
    file://0256-wikiheaders-ignore-wiki-s-README-FrontPage.md.patch \
    file://0257-Fixed-SDL-windows-getting-the-maximized-state-after-.patch \
    file://0258-wikiheaders-Use-Windows-endlines-in-the-source-Unix-.patch \
    file://0259-wikiheaders-Sort-pages-before-listing-them-in-README.patch \
    file://0260-Sync-wiki-headers.patch \
    file://0261-docs-Removed-bogus-file-from-wiki-bridge.patch \
    file://0262-Follow-the-same-pattern-for-releasing-the-window-dat.patch \
    file://0263-Don-t-clobber-an-existing-entry-with-a-different-ver.patch \
    file://0264-Fixed-typo-in-previous-cherry-pick.patch \
    file://0265-dataqueue-Removed-non-public-SDL_ReserveSpaceInDataQ.patch \
    file://0266-dataqueue-Make-thread-safe.patch \
    file://0267-dynapi-replace-uses-of-deprecated-SDL_assert_state-a.patch \
    file://0268-evdev_kbd-Use-current-keymap.patch \
    file://0269-cmake-use-compatible-interface-properties-to-disallo.patch \
    file://0270-Fix-Xbox-One-gamepad-axis-assignment-on-SDL_JOYSTICK.patch \
    file://0271-Added-mapping-for-the-Xbox-Elite-Core-controller-con.patch \
    file://0272-Fixed-which-window-we-check-flags-for-when-updating-.patch \
    file://0273-If-we-re-not-the-current-fullscreen-window-and-we-do.patch \
    file://0274-Use-SDL_GL_DeleteContext-instead-of-Cocoa_GL_DeleteC.patch \
    file://0275-Disassociate-the-SDLOpenGLContext-from-the-view-befo.patch \
    file://0276-tests-added-DHAVE_SIGNAL_H-to-CFLAGS-in-watcom-makef.patch \
    file://0277-Fixed-uninitialized-variable.patch \
    file://0278-fix-SDL_FindFreePlayerIndex-so-it-can-really-return-.patch \
    file://0279-Make-mappings-for-Retrolink-SNES-Controller-with-SDL.patch \
    file://0280-wayland-Always-use-a-scale-factor-of-1-for-exclusive.patch \
    file://0281-tests-Always-set-valid-dimensions-for-the-fullscreen.patch \
    file://0282-Fixed-the-documentation-for-SDL_SetRelativeMouseMode.patch \
    file://0283-Fixed-incorrect-modifier-keys-handling-on-macOS.patch \
    file://0284-Removed-guard-around-the-enabled-assertions-support-.patch \
    file://0285-If-the-client-rect-is-empty-use-the-last-known-windo.patch \
    file://0286-Code-style-changed-sizeof-foo-to-sizeof-foo-thanks-s.patch \
    file://0287-Wait-for-the-GCController-framework-to-see-IOKit-dev.patch \
    file://0288-Removed-a-duplicate-delay-accidentally-added-during-.patch \
    file://0289-Added-header-for-SDL_Delay.patch \
    file://0290-fix-bad-merge-of-sizeof-style-patch.patch \
    file://0291-Uses-integer-arithmetics-in-SDL_ResampleAudio.patch \
    file://0292-Specify-bash-for-androidbuildlibs.sh.patch \
    file://0293-Fixed-build-warning-on-Android.patch \
    file://0294-Removed-space-between-sizeof-and-parentheses.patch \
    file://0295-Added-support-for-the-trigger-buttons-on-the-Victrix.patch \
    file://0296-Android-indicate-gamepaddb-entries-where-axis-order-.patch \
    file://0297-Ignore-the-PS4-packet-CRC-if-it-s-not-being-set-corr.patch \
    file://0298-cmake-get_filename_component-EXT-retturns-extension-.patch \
    file://0299-Refresh-generation-of-SDL_blit_auto.c.patch \
    file://0300-Simplify-SDL_BLENDMODE_MUL.patch \
    file://0301-Simplify-SDL_BLENDMODE_MUL-in-sdlgenblit.pl.patch \
    file://0302-Refresh-generation-of-SDL_blit_auto.c-after-simplify.patch \
    file://0303-Change-SDL_BLENDMODE_MUL-for-gl-renderers.patch \
    file://0304-wasapi-Force-WIN_CoInitialize-duing-device-open.patch \
    file://0305-Fixed-SDL_RenderSetVSync-does-not-update-flags-if-si.patch \
    file://0306-Added-gamepad-mapping-for-Flydigi-Vader-2-with-the-l.patch \
    file://0307-wikiheaders.pl-make-it-work-with-older-perl-versions.patch \
    file://0308-backport-x11-sdl2-fixes.patch \
    file://0309-Android-Fix-missing-type-in-SDLControllerManager.patch \
    file://0310-Android-Fix-mismatching-JNI-method-signature.patch \
    file://0311-Made-the-Android-documentation-more-clear-and-unders.patch \
    file://0312-testgles2_sdf-Call-correct-function-to-get-shader-in.patch \
    file://0313-events-Increase-the-size-of-the-name-buffer-when-log.patch \
    file://0314-byteswap-Don-t-use-intrinsic-byteswap-functions-with.patch \
    file://0315-cmake-increase-threshold-for-stack-probes.patch \
    file://0316-cpuinfo-use-__cpuidex-instead-of-__cpuid.patch \
    file://0317-cmake-new-LLVM-based-Intel-compiler-does-not-recogni.patch \
    file://0318-testautomation_math-avoid-equality-tests-with-INFINI.patch \
    file://0319-cmake-add-support-for-building-with-Intel-C-compiler.patch \
    file://0320-ci-test-with-old-Intel-compiler-new-oneAPI-compiler.patch \
    file://0321-cmake-add-Q_no-use-libirc-flag-when-building-a-no-li.patch \
    file://0322-Implement-_intel_fast_-memcpy-memset.patch \
    file://0323-cmake-disable-warnings-in-libm-warning-about-EMMS-in.patch \
    file://0324-SDL_blit_copy-Don-t-call-potentially-FPU-using-SDL_m.patch \
    file://0325-Fix-clang-tidy-error-on-LLVM-16.patch \
    file://0326-SDL_hidapi_steam.c-Fix-compilation-under-c2x.patch \
    file://0327-Increased-precision-for-PS4-sensor-data-conversion.patch \
    file://0328-Fixed-the-accelerometer-sensitivity-for-the-Armor-X-.patch \
    file://0329-Fixed-bug-7515-Window-still-grabbed-after-destroying.patch \
    file://0330-Safety-fix-clear-_this-current_glwin-when-destroying.patch \
    file://0331-Safety-fix-clear-_this-wakeup_window-when-destroying.patch \
    file://0332-testsurround-fix-channel-names.patch \
    file://0333-video-blit-fix-Wimplicit-fallthrough-warnings.patch \
    file://0334-testautomation_audio-fix-Wimplicit-fallthrough-warni.patch \
    file://0335-video-fix-warnings-about-unused-variables-when-build.patch \
    file://0336-Fix-remaining-Wimplicit-fallthrough-warnings.patch \
    file://0337-Fixed-the-accelerometer-and-gyro-axes-for-the-Armor-.patch \
    file://0338-Fixed-gyro-values-for-the-Armor-X-Pro-controller.patch \
    file://0339-The-Xinmotek-Controller-is-used-in-multiple-products.patch \
    file://0340-Split-up-CFLAGS-construction-so-it-can-be-overridden.patch \
    file://0341-include-Fixed-a-C-style-single-line-comment.patch \
    file://0342-x11-Don-t-allow-the-changing-of-certain-scancodes.patch \
    file://0343-Haiku-use-a-BLooper-for-events.patch \
    file://0344-Fixed-analog-triggers-on-the-DualSense-controller.patch \
    file://0345-Don-t-probe-for-PlayStation-controllers-when-we-alre.patch \
    file://0346-Fixed-crash-if-dbus-can-t-be-initialized.patch \
    file://0347-fix-build-after-commit-22685556e5d9fc2e2a7023075e51b.patch \
    file://0348-Fixed-crash-if-joystick-hwdata-NULL-device-driver-NU.patch \
    file://0349-The-macOS-minimum-deployment-target-is-now-10.11.patch \
    file://0350-Fix-key-code-names-for-ISO-keyboard-layouts.patch \
    file://0351-The-latest-Armor-X-Pro-firmware-update-fixes-the-sig.patch \
    file://0352-Clarified-the-expected-sensor-value-when-a-game-cont.patch \
    file://0353-More-defensive-coding-against-dangling-device-pointe.patch \
    file://0354-cmake-allow-users-of-sdl2-config.cmake-to-not-add-mw.patch \
    file://0355-Report-PS3-accelerometer-values-in-m-s2-instead-of-G.patch \
    file://0356-Check-return-value-of-SDL_malloc.patch \
    file://0357-hidapi-mac-import-mainstream-commit-c1b9d2ad.patch \
    file://0358-hidapi-mac-replace-sprintf-uses-with-snprintf.patch \
    file://0359-wayland-Fixes-a-memory-leak-wheere-primary-selection.patch \
    file://0360-wayland-Destroy-proxy-wrappers-and-callbacks-before-.patch \
    file://0361-By-default-OpenBSD-uses-Linux-controller-mappings.patch \
    file://0362-Removed-memset_pattern4-from-SDL-headers.patch \
    file://0363-Fix-bug-memory-acess.patch \
    file://0364-SDL_blit_N.c-Move-ppc64le-swizzle-outside-of-loop.patch \
    file://0365-Removed-redundant-__powerpc__-check.patch \
    file://0366-coreaudio-Flush-stop-the-AudioQueue-before-disposing.patch \
    file://0367-Changed-all-variadic-macros-into-fixed-thanks-Wohlst.patch \
    file://0368-Check-to-make-sure-the-Windows-joystick-device-has-b.patch \
    file://0369-blit-Add-a-case-for-8-bit-blits-that-sdl12-compat-ex.patch \
    file://0370-SDL-emscripten-port-preventDefault-should-not-be-cal.patch \
    file://0371-dynapi-Accept-a-comma-separated-list-of-libraries-to.patch \
    file://0372-audio-Load-.WAV-files-with-format-blockalign-0.patch \
    file://0373-power-On-Linux-compare-status-strings-as-case-insens.patch \
    file://0374-style-fixes-for-SDL_PROC-macros.patch \
    file://0375-testgles2_sdf-build-with-CMake-fix-build-errors-warn.patch \
    file://0376-test-testgles2_sdf.c-type-fixes-from-commit-e26e893d.patch \
    file://0377-Added-support-for-the-Astro-C40-in-Xbox-360-mode.patch \
    file://0378-Moved-the-controller-list-out-so-it-can-be-included-.patch \
    file://0379-Undo-name-change-for-the-controller-list.patch \
    file://0380-Make-sure-the-sentinel-is-at-the-end-of-the-current-.patch \
    file://0381-Added-the-hint-SDL_HINT_ENABLE_SCREEN_KEYBOARD-to-co.patch \
    file://0382-Stop-beep-when-running-iOS-apps-on-ARM-based-Macs.patch \
    file://0383-Fix-Xbox-link-error-from-IsRectEmpty.patch \
    file://0384-Don-t-map-the-top-keyboard-row-to-numbers-when-using.patch \
    file://0385-Use-numeric-codes-for-Android-versions-to-avoid-SDK-.patch \
    file://0386-Fixed-reporting-backspace-key-if-there-is-no-text-in.patch \
    file://0387-Fixed-handling-the-Saitek-P3600-which-doesn-t-use-th.patch \
    file://0388-Fixed-duplicate-Joy-Con-controllers-on-macOS.patch \
    file://0389-wayland-Validate-surfaces-and-window-data-before-sen.patch \
    file://0390-Fix-unused-variable-warnings.patch \
    file://0391-Document-the-Android-SDK-versions-checked-in-Java-co.patch \
    file://0392-Updated-source-to-match-SDL-function-prototype-style.patch \
    file://0393-Disable-unused-local-typedefs-warning.patch \
    file://0394-video-Only-specify-some-GL-context-attributes-if-not.patch \
    file://0395-Fix-Wunused-function-warning-when-configuring-with-D.patch \
    file://0396-fix-mingw-build-failures-in-CI-with-clang-tidy.patch \
    file://0397-Added-support-for-printing-wide-strings-using-ls-syn.patch \
    file://0398-wasapi-Deal-with-HDMI-or-DisplayPort-based-audio-dev.patch \
    file://0399-cmake-allow-include-SDL2-SDL.h.h-when-using-SDL2-as-.patch \
    file://0400-windows-SDL_immdevice-needs-SDL_timer.h-include.patch \
    file://0401-windows-SDL_Delay-expects-a-32-bit-integer.patch \
    file://0402-Disable-SDL_JOYSTICK_RAWINPUT_XINPUT.patch \
    file://0403-Fixed-build-warning.patch \
    file://0404-VisualC-turn-on-multi-processor-compilation.patch \
    file://0405-windows-Don-t-allow-non-resizable-windows-to-be-maxi.patch \
    file://0406-x11-Attempt-to-wait-for-SDL_MaximizeWindow-to-comple.patch \
    file://0407-testautomation_guid.c-fix-integer-warning-in-32-bit-.patch \
    file://0408-wayland-reset-orientation-bitmask-before-reading-val.patch \
    file://0409-hints-clarify-support-for-comma-separated-values-for.patch \
    file://0410-Fixed-WGI-immediately-being-correlated-with-raw-inpu.patch \
    file://0411-Don-t-use-raw-input-while-Remote-Desktop-is-active.patch \
    file://0412-Fixed-build-if-SDL_JOYSTICK_RAWINPUT_MATCHING-isn-t-.patch \
    file://0413-Fixed-detection-of-the-Steam-Virtual-Gamepad-on-macO.patch \
    file://0414-Revert-Fixed-detection-of-the-Steam-Virtual-Gamepad-.patch \
    file://0415-Steam-uses-a-different-VID-PID-for-the-Steam-Virtual.patch \
    file://0416-Fixed-typo-in-cherry-pick-thanks-HadesD.patch \
    file://0417-Fixed-building-with-the-16.1.4479499-Android-toolcha.patch \
    file://0418-Only-convert-the-result-of-XLookupString-if-it-s-not.patch \
    file://0419-fix-MSVC-build-error.patch \
    file://0420-Fixed-SDL_iconv_string-truncation-when-handling-SDL_.patch \
    file://0421-Always-allocate-zt-in-output-of-SDL_iconv_string.patch \
    file://0422-Don-t-bother-re-encoding-Latin1-characters-in-the-AS.patch \
    file://0423-fixed-os-2-mouse-relative-motion-not-working-thanks-.patch \
    file://0424-git-commit-m-cmake-set-maximum-policy-to-3.5.patch \
    file://0425-x11-check-if-window-size-position-has-changed-during.patch \
    file://0426-further-mouse-relative-motion-fix-for-os-2-thanks-An.patch \
    file://0427-Fixed-reading-input-from-the-Razer-Atrox-Arcade-Stic.patch \
    file://0428-Only-update-the-serial-number-if-it-hasn-t-already-b.patch \
    file://0429-Fixed-querying-device-info-on-the-MOBAPAD-M073.patch \
    file://0430-Make-it-clear-that-you-can-t-mix-2D-rendering-and-th.patch \
    file://0431-Fixed-build.patch \
    file://0432-SDL_dynapi.c-minor-cosmetics.patch \
    file://0433-cocoa-Warp-mouse-to-center-of-window-before-enabling.patch \
    file://0434-Reduce-the-chance-of-destroying-the-joystick-mutex-w.patch \
    file://0435-Fixed-n3ds-build.patch \
    file://0436-Fixed-enumerating-Steam-Controllers-on-iOS.patch \
    file://0437-linux-Reduce-magic-numbers-when-mapping-gamepad-axes.patch \
    file://0438-linux-Improve-gamepad-mapping-heuristic-to-accept-An.patch \
    file://0439-Fixed-joystick-vendor-detection-in-Linux-automatic-g.patch \
    file://0440-Added-automatic-mapping-for-Xbox-Elite-paddles-using.patch \
    file://0441-fixed-build-after-commit-d2372c853843def01b7adb9872c.patch \
    file://0442-libsdl-bug-fix-for-muitl-display-get-wrong-index-for.patch \
    file://0443-libsdl-use-window-title-for-xdg-appid.patch \
    file://0444-libsdl-Add-dpms-setting-for-guest-S3-feature.patch \
    file://0445-wayland-protocols-add-secure-display-xml.patch \
    file://0446-wayland-display-add-param-to-identify-sdl-xdg-output.patch \
    file://0447-wayland-display-register-secure-display-global-servi.patch \
    file://0448-wayland-display-add-api-to-send-secure-display-roi-t.patch \
    file://0449-xdg-shell-update-xdg-version-for-dpms.patch \
    file://0450-wayland-display-set-app-id-for-xdg-toplevel-window.patch \
    file://0451-Wayland-Add-interface-for-support-hdcp.patch \
    file://0452-Wayland-dynamically-switched-egl-surface.patch \
    file://0453-bug-fix-for-crash-when-destroy-windows.patch \
    file://0454-wayland-identify-secure-display-output-by-window-ind.patch \
    file://0455-Revert-wayland-display-add-param-to-identify-sdl-xdg.patch \
    file://0456-wayland-add-a-new-sdl-window-flag-for-crc-check.patch \
    file://0457-wayland-fixup-one-frame-snow-pattern-issue.patch \
    file://0458-Fixed-create-window-failed-when-not-support-EGL_PROT.patch \
    "
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=31f575634fd56b27fc6b6cbe8dc9bd38"
SRC_URI[sha256sum] = "8a0456dd2765f413beecccd9cac7dce74141f87d1ee855808bd95098abafe2b4"

PV = "${XEN_REL}+${SRCREV}"

S = "${WORKDIR}/git"

inherit autotools lib_package binconfig-disabled pkgconfig

DEPENDS = "dbus libxext libfm libdrm mesa alsa-lib virtual/libgles2 virtual/libgbm virtual/egl pulseaudio wayland-native wayland wayland-protocols libxkbcommon virtual/libx11 libxext libxrandr libxrender"
BINCONFIG = "${bindir}/sdl2-config"

CVE_PRODUCT = "simple_directmedia_layer sdl"

FILES:${PN} = "\
/usr/share/licenses \
/usr/share/licenses/SDL2 \
/usr/share/licenses/SDL2/LICENSE.txt \
/usr/lib/libSDL2-2.0.so.0.2700.0 \
/usr/lib/libSDL2-2.0.so.0 \
"
do_configure() {
	oe_runconf
}
